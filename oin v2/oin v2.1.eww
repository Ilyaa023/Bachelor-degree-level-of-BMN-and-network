<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\actual\oin v2\oin.ewp</path>
    </project>
    <batchBuild />
</workspace>
